## drivers/Kconfig
```kconfig
# Copyright (c) 2021 Nordic Semiconductor ASA
# SPDX-License-Identifier: Apache-2.0

menu "Drivers"
rsource "odroid_go_buttons/Kconfig.odroid_go_buttons"
endmenu
```
